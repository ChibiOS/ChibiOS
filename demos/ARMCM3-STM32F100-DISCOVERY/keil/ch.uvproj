# Keil uVision project ch.uvproj, settings and files
target Demo (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ch
  c flags: Optim=4 oTime=1
  c define: __heap_base__=Image$$RW_IRAM1$$ZI$$Limit __heap_end__=Image$$RW_IRAM2$$Base
  c include: ..\;..\..\..\os\kernel\include;..\..\..\os\ports\RVCT\ARMCMx;..\..\..\os\ports\RVCT\ARMCMx\STM32;..\..\..\os\hal\include;..\..\..\os\hal\platforms\STM32;..\..\..\boards\OLIMEX_STM32_P103;..\..\..\test
  asm misc: --cpreproc
  asm include: ..\..\..\boards\OLIMEX_STM32_P103;..\..\..\os\ports\RVCT\ARMCMx\STM32
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20002000 size 0x1
  group board
    ../../../boards/ST_STM32VL_DISCOVERY/: board.c board.h
  group port
    ../../../os/ports/RVCT/ARMCMx/: cstartup.s chcoreasm_v7m.s chcore.c chcore_v7m.c nvic.c chcore.h chcore_v7m.h chtypes.h nvic.h
    ../../../os/ports/RVCT/ARMCMx/STM32/: vectors.s
  group kernel
    ../../../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
    ../../../os/kernel/include/: ch.h chbsem.h chcond.h chdebug.h chdynamic.h chevents.h chfiles.h chheap.h chinline.h chioch.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group hal
    ../../../os/hal/src/: adc.c can.c hal.c i2c.c mac.c mmc_spi.c pal.c pwm.c serial.c spi.c uart.c
    ../../../os/hal/include/: adc.h can.h hal.h i2c.h mac.h mii.h mmc_spi.h pal.h pwm.h serial.h spi.h uart.h
  group platform
    ../../../os/hal/platforms/STM32/: adc_lld.c can_lld.c hal_lld.c pal_lld.c pwm_lld.c serial_lld.c spi_lld.c stm32_dma.c uart_lld.c adc_lld.h can_lld.h core_cm3.h hal_lld.h hal_lld_f103.h pal_lld.h pwm_lld.h serial_lld.h spi_lld.h stm32_dma.h stm32f10x.h uart_lld.h
  group test
    ../../../test/: test.c testbmk.c testdyn.c testevt.c testheap.c testmbox.c testmsg.c testmtx.c testpools.c testqueues.c testsem.c testthd.c test.h testbmk.h testdyn.h testevt.h testheap.h testmbox.h testmsg.h testmtx.h testpools.h testqueues.h testsem.h testthd.h
  group demo
    ../: main.c mcuconf.h chconf.h halconf.h
