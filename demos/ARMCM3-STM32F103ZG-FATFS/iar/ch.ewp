# IAR project ch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxG ST STM32F10xxG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SHELL_USE_IPRINTF=FALSE
  ICCARM.CCIncludePath2: ..\; ..\..\..\os\kernel\include; ..\..\..\os\ports\IAR\ARMCMx; ..\..\..\os\ports\IAR\ARMCMx\STM32; ..\..\..\os\hal\include; ..\..\..\os\hal\platforms\STM32; ..\..\..\os\various; ..\..\..\boards\ST_STM3210E_EVAL; ..\..\..\ext\fatfs\src; ..\..\..\test
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\; ..\..\..\os\ports\IAR\ARMCMx\STM32; ..\..\..\boards\ST_STM3210E_EVAL
  OBJCOPY.OOCOutputFile: ch.srec
  ILINK.IlinkOutputFile: ch.out
  ILINK.IlinkIcfFile: ch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SHELL_USE_IPRINTF=FALSE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: ch.hex
  group (top)
    ../: chconf.h halconf.h main.c mcuconf.h
  group board
    ../../../boards/ST_STM3210E_EVAL/: board.c board.h
  group fatfs
    ../../../ext/fatfs/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../../../ext/fatfs/src/option/: syncobj.c
  group os/hal/include
    ../../../os/hal/include/: adc.h can.h gpt.h hal.h i2c.h icu.h mac.h mii.h mmc_spi.h pal.h pwm.h sdc.h serial.h serial_usb.h spi.h uart.h usb.h usb_cdc.h
  group os/hal/src
    ../../../os/hal/src/: adc.c can.c gpt.c hal.c i2c.c icu.c mac.c mmc_spi.c pal.c pwm.c sdc.c serial.c serial_usb.c spi.c uart.c usb.c
  group os/kernel/include
    ../../../os/kernel/include/: ch.h chcond.h chdebug.h chdynamic.h chevents.h chheap.h chinline.h chioch.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group os/kernel/src
    ../../../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
  group os/platform
    ../../../os/hal/platforms/STM32/: adc_lld.c adc_lld.h can_lld.c can_lld.h core_cm3.h gpt_lld.c gpt_lld.h hal_lld.c hal_lld.h hal_lld_f100.h hal_lld_f103.h hal_lld_f105_f107.h icu_lld.c icu_lld.h pal_lld.c pal_lld.h pwm_lld.c pwm_lld.h sdc_lld.c sdc_lld.h serial_lld.c serial_lld.h spi_lld.c spi_lld.h stm32_dma.c stm32_dma.h stm32_usb.h stm32f10x.h uart_lld.c uart_lld.h usb_lld.c usb_lld.h
  group os/port
    ../../../os/ports/IAR/ARMCMx/: chcore.c chcore.h chcore_v7m.c chcore_v7m.h chcoreasm_v7m.s chtypes.h cstartup.s nvic.c nvic.h
  group os/port/STM32
    ../../../os/ports/IAR/ARMCMx/STM32/: cmparams.h vectors.s
  group os/various
    ../../../os/various/: shell.c shell.h
  group test
    ../../../test/: test.c test.h testbmk.c testbmk.h testdyn.c testdyn.h testevt.c testevt.h testheap.c testheap.h testmbox.c testmbox.h testmsg.c testmsg.h testmtx.c testmtx.h testpools.c testpools.h testqueues.c testqueues.h testsem.c testsem.h testthd.c testthd.h
