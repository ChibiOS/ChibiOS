# IAR project ch.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5437 MSP430F5437
  General.GStackSize2: 512
  General.GHeapSize2: 512
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\; ..\..\..\boards\NONSTANDARD_MSP430_F5437; ..\..\..\os\hal\include; ..\..\..\os\hal\platforms\MSP430X; ..\..\..\os\hal\platforms\MSP430X\F5XX_F6XX_CORE_LIB; ..\..\..\os\kernel\include; ..\..\..\os\ports\common\MSP430X; ..\..\..\test
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5437.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: asmdefines.s43
    ../: chconf.h halconf.h main.c mcuconf.h readme.txt
  group board
    ../../../boards/NONSTANDARD_MSP430_F5437/: board.c board.h
  group os/hal/include
    ../../../os/hal/include/: adc.h can.h ext.h gpt.h hal.h i2c.h icu.h mac.h mii.h mmc_spi.h pal.h pwm.h rtc.h sdc.h serial.h serial_usb.h spi.h tm.h uart.h usb.h usb_cdc.h
  group os/hal/platform
    ../../../os/hal/platforms/MSP430X/: hal_lld.c hal_lld.h pal_lld.c pal_lld.h serial_lld.c serial_lld.h
  group os/hal/platform/F5XX_F6XX_CORE_LIB
    ../../../os/hal/platforms/MSP430X/F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h HAL_MACROS.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_TLV.c HAL_TLV.h HAL_UCS.c
    ../../../os/hal/platforms/MSP430X/F5XX_F6XX_CORE_LIB/: HAL_PMM.h HAL_UCS.h
  group os/hal/src
    ../../../os/hal/src/: adc.c can.c ext.c gpt.c hal.c i2c.c icu.c mac.c mmc_spi.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c tm.c uart.c usb.c
  group os/kernel/include
    ../../../os/kernel/include/: ch.h chcond.h chdebug.h chdynamic.h chevents.h chheap.h chinline.h chioch.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group os/kernel/src
    ../../../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
  group os/ports
    ../../../os/ports/common/MSP430X/: chcore.c chcore.h chtypes.h
  group os/various
    ../../../os/various/: chprintf.c chprintf.h evtimer.c evtimer.h shell.c shell.h
  group test
    ../../../test/: test.c test.h testbmk.c testbmk.h testdyn.c testdyn.h testevt.c testevt.h testheap.c testheap.h testmbox.c testmbox.h testmsg.c testmsg.h testmtx.c testmtx.h testpools.c testpools.h testqueues.c testqueues.h testsem.c testsem.h testthd.c testthd.h
