# Keil uVision project ch.uvprojx, settings and files
target Demo (6160000::V6.16::ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ch +hex
  c flags: Optim=6 oTime=1 uC99=1 v6Lang=3 v6LangP=3
  c define: CORTEX_USE_FPU=0 TEST_CFG_SIZE_REPORT=0 SHELL_CMD_TEST_ENABLED=0 __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base
  c include: ..;..\cfg;..\..\..\..\os\common\ext\ARM\CMSIS\Core\Include;..\..\..\..\os\common\ext\ST\STM32G4xx;..\..\..\..\os\license;..\..\..\..\os\common\portability\ARMC6;..\..\..\..\os\common\startup\ARMCMx\devices\STM32G4xx;..\..\..\..\os\rt\include;..\..\..\..\os\oslib\include;..\..\..\..\os\common\ports\ARM-common;..\..\..\..\os\common\ports\ARMv7-M;..\..\..\..\os\hal\osal\rt-nil;..\..\..\..\os\hal\include;..\..\..\..\os\hal\lib\streams;..\..\..\..\os\hal\boards\ST_NUCLEO64_G474RE;..\..\..\..\os\hal\ports\common\ARMCMx;..\..\..\..\os\hal\ports\STM32\STM32G4xx;..\..\..\..\os\hal\ports\STM32\LLD\DMAv1;..\..\..\..\os\hal\ports\STM32\LLD\EXTIv1;..\..\..\..\os\hal\ports\STM32\LLD\FDCANv1;..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2;..\..\..\..\os\hal\ports\STM32\LLD\RCCv1;..\..\..\..\os\hal\ports\STM32\LLD\SYSTICKv1;..\..\..\..\os\hal\ports\STM32\LLD\TIMv1;..\..\..\..\os\hal\ports\STM32\LLD\USART;..\..\..\..\os\hal\ports\STM32\LLD\USARTv3;..\..\..\..\os\various\shell;..\..\..\..\os\test\include;..\..\..\..\test\rt\source\test;..\..\..\..\test\oslib\source\test
  asm define: CORTEX_USE_FPU=0
  asm include: ..\;..\cfg;..\..\..\..\os\license;..\..\..\..\os\common\startup\ARMCMx\devices\STM32G4xx;..\..\..\..\os\common\ports\ARMv7-M;..\..\..\..\os\hal\boards\ST_NUCLEO64_G474RE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x1
  group cmsis_arm
    ../../../../os/common/ext/ARM/CMSIS/Core/Include/: core_cm4.h
  group cmsis_st
    ../../../../os/common/ext/ST/STM32G4xx/: stm32g4xx.h stm32g474xx.h system_stm32g4xx.h
  group os_license
    ../../../../os/license/: chcustomer.h chlicense.h chversion.h
  group os_compiler
    ../../../../os/common/portability/ARMC6/: ccportab.h
  group os_startup
    ../../../../os/common/startup/ARMCMx/compilers/ARMC6/: cstartup.S vectors.S
  group os_startup_device
    ../../../../os/common/startup/ARMCMx/devices/STM32G4xx/: cmparams.h
  group os_rt
    ../../../../os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chinstances.c chmsg.c chmtx.c chregistry.c chrfcu.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chtrace.c chvt.c
    ../../../../os/rt/include/: ch.h chalign.h chchecks.h chcond.h chdebug.h chdynamic.h chearly.h chevents.h chinstances.h chlists.h chmsg.h chmtx.h chobjects.h chport.h chregistry.h chrestrictions.h chrfcu.h chschd.h chsem.h chstats.h chsys.h chthreads.h chtime.h chtm.h chtrace.h chvt.h
  group os_oslib
    ../../../../os/oslib/src/: chdelegates.c chfactory.c chmboxes.c chmemchecks.c chmemcore.c chmemheaps.c chmempools.c chobjcaches.c chpipes.c
    ../../../../os/oslib/include/: chbsem.h chdelegates.h chfactory.h chjobs.h chlib.h chmboxes.h chmemchecks.h chmemcore.h chmemheaps.h chmempools.h chobjcaches.h chobjfifos.h chpipes.h
  group os_port_armv7m
    ../../../../os/common/ports/ARMv7-M/: chcore.c chcore.h mpu.h
    ../../../../os/common/ports/ARMv7-M/compilers/ARMC6/: chcoreasm.S
  group os_osal
    ../../../../os/hal/osal/rt-nil/: chcore_timer.h osal.c osal.h
  group os_hal
    ../../../../os/hal/src/: hal.c hal_adc.c hal_buffered_serial.c hal_buffers.c hal_can.c hal_crypto.c hal_dac.c hal_efl.c hal_flash.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_sio.c hal_spi.c hal_spi_v1.inc hal_spi_v2.inc hal_st.c hal_trng.c hal_uart.c hal_usb.c hal_wdg.c hal_wspi.c
    ../../../../os/hal/include/: hal.h hal_adc.h hal_buffered_serial.h hal_buffers.h hal_can.h hal_channels.h hal_crypto.h hal_dac.h hal_efl.h hal_files.h hal_flash.h hal_gpt.h hal_i2c.h hal_i2s.h hal_icu.h hal_ioblock.h hal_mac.h hal_mii.h hal_mmc_spi.h hal_mmcsd.h hal_objects.h hal_pal.h hal_persistent.h hal_pwm.h hal_queues.h hal_rtc.h hal_sdc.h hal_serial.h hal_serial_usb.h hal_sio.h hal_spi.h hal_spi_v1.h hal_spi_v2.h hal_st.h hal_streams.h hal_trng.h hal_uart.h hal_usb.h hal_usb_cdc.h hal_wdg.h hal_wspi.h
  group os_hal_armcmx
    ../../../../os/hal/ports/common/ARMCMx/: cache.h mpu_v7m.h nvic.c nvic.h
  group os_hal_platform
    ../../../../os/hal/ports/STM32/STM32G4xx/: hal_efl_lld.c hal_efl_lld.h hal_lld.c hal_lld.h stm32_dmamux.h stm32_isr.c stm32_isr.h stm32_rcc.h stm32_registry.h
  group os_hal_lld
    ../../../../os/hal/ports/STM32/LLD/GPIOv2/: hal_pal_lld.c hal_pal_lld.h stm32_gpio.h
    ../../../../os/hal/ports/STM32/LLD/USARTv3/: hal_sio_lld.c hal_sio_lld.h stm32_usart.h
    ../../../../os/hal/ports/STM32/LLD/SYSTICKv1/: hal_st_lld.c hal_st_lld.h
  group os_hal_board
    ../../../../os/hal/boards/ST_NUCLEO64_G474RE/: board.c board.h
  group os_hal_lib_streams
    ../../../../os/hal/lib/streams/: bufstreams.c bufstreams.h chprintf.c chprintf.h chscanf.c chscanf.h memstreams.c memstreams.h nullstreams.c nullstreams.h
  group os_shell
    ../../../../os/various/shell/: shell.c shell.h shell_cmd.c shell_cmd.h
  group os_test
    ../../../../os/test/src/: ch_test.c ch_test_printf.c
    ../../../../os/test/include/: ch_test.h
    ../../../../test/rt/source/test/: rt_test_root.c rt_test_root.h rt_test_sequence_001.c rt_test_sequence_001.h rt_test_sequence_002.c rt_test_sequence_002.h rt_test_sequence_003.c rt_test_sequence_003.h rt_test_sequence_004.c rt_test_sequence_004.h rt_test_sequence_005.c rt_test_sequence_005.h rt_test_sequence_006.c rt_test_sequence_006.h rt_test_sequence_007.c rt_test_sequence_007.h rt_test_sequence_008.c rt_test_sequence_008.h rt_test_sequence_009.c rt_test_sequence_009.h rt_test_sequence_010.c rt_test_sequence_010.h rt_test_sequence_011.c rt_test_sequence_011.h rt_test_sequence_012.c rt_test_sequence_012.h
    ../../../../test/oslib/source/test/: oslib_test_root.c oslib_test_root.h oslib_test_sequence_001.c oslib_test_sequence_001.h oslib_test_sequence_002.c oslib_test_sequence_002.h oslib_test_sequence_003.c oslib_test_sequence_003.h oslib_test_sequence_004.c oslib_test_sequence_004.h oslib_test_sequence_005.c oslib_test_sequence_005.h oslib_test_sequence_006.c oslib_test_sequence_006.h oslib_test_sequence_007.c oslib_test_sequence_007.h oslib_test_sequence_008.c oslib_test_sequence_008.h oslib_test_sequence_009.c oslib_test_sequence_009.h
  group cfg
    ../cfg/: chconf.h halconf.h mcuconf.h
  group application
    ../: main.c
