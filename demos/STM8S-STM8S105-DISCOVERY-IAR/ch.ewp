# IAR project ch.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\..\os\kernel\include; ..\..\os\ports\IAR\STM8; ..\..\os\hal\include; ..\..\os\hal\platforms\STM8S; ..\..\boards\ST_STM8S_DISCOVERY
  ICCSTM8.IccLang: 0
  ASTM8.AsmIncludePath: $PROJ_DIR$; ..\..\os\ports\IAR\STM8
  OBJCOPY.OOCOutputFile: ch.srec
  ILINK.IlinkOutputFile: ch.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: chconf.h halconf.h main.c mcuconf.h
  group board
    ../../boards/ST_STM8S_DISCOVERY/: board.c board.h
  group os/hal/include
    ../../os/hal/include/: hal.h pal.h serial.h spi.h
  group os/hal/src
    ../../os/hal/src/: hal.c pal.c serial.c spi.c
  group os/kernel/include
    ../../os/kernel/include/: ch.h chbsem.h chcond.h chdebug.h chdynamic.h chevents.h chfiles.h chheap.h chinline.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group os/kernel/src
    ../../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
  group os/platform
    ../../os/hal/platforms/STM8S/: hal_lld.c hal_lld.h pal_lld.c pal_lld.h serial_lld.c serial_lld.h spi_lld.c spi_lld.h stm8s.h stm8s_type.h
  group os/port
    ../../os/ports/IAR/STM8/: chcore.c chcore.h chcore_stm8.s chtypes.h
